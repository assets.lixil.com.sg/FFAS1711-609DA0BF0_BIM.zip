Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-23T21:21:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 23 21:21:21 2025 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\f30d796c-d6b4-47e1-8906-580106b29398\d895c900-4bfc-4f1c-9495-2ba705d814e7\ifc * Database version: 5507 * Database creation date: Thu Oct 23 21:21:19 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 23 21:21:20 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 23 21:21:20 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (3)
Description: Flow
Name | FlowDirection
Port_348410 | SINK
2 x Port_348410 | SOURCE

# IfcFlowTerminal: FFAS1711-609DA0BF0_REVIT:FFAS1711-609DA0BF0, FFAS1711-609DA0BF0_REVIT:FFAS1711-609DA0BF0:348410
In: Level 1
Type - Material: American Standard - Brass - Polished Warm Sunset
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: FFAS1711-609DA0BF0
Pset_DistributionFlowElementCommon - Reference: FFAS1711-609DA0BF0; sets with these values: 2
